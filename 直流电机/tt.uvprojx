# Keil uVision project tt.uvprojx, settings and files
target 直流电机 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: tt +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c
  group ::Device
    E:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/2.1.0/Device/StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c
    E:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/2.1.0/RTE_Driver/: GPIO_STM32F10x.c
    RTE/Device/STM32F103C8/: RTE_Device.h startup_stm32f10x_md.s stm32f10x_conf.h system_stm32f10x.c
software components: CMSIS:CORE 3.30.0, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:RCC 3.5.0

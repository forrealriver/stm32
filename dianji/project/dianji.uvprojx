# Keil uVision project dianji.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: dianji +hex
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../user/: main.c
  group ::Device
    RTE/Device/STM32F103C8/: RTE_Device.h startup_stm32f10x_md.s system_stm32f10x.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
